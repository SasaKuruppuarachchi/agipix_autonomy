Commit message: Namespaced frame ids

File: agi_viz/assets/agipix.urdf (robot description, URDF)
Before this commit: robot agipix, 1 links, 0 joints
Links:
- removed link drone0/base_link
- added link base_link; visual mesh filename=package://agi_viz/assets/meshes/agipix.stl
